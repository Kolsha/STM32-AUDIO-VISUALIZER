# Keil uVision project VISUALIZER.uvprojx, settings and files
target VISUALIZER (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F078RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: VISUALIZER
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source
    ./: adc_control.h audio_samples.h btn_utils.h fix_fft.h led_table.h spi_control.h sys_tick.h adc_control.c btn_utils.c fix_fft.c led_table.c main.c spi_control.c sys_tick.c
software components: CMSIS:CORE 5.0.2, Device:Startup 1.0.0
